# Keil uVision project accelerometer.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOSDemo
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, RVDS_ARMCM4F
  c include: ..\FreeRTOS_Example;.\FreeRTOS;.\FreeRTOS\Source\include;.\USART;.\STM32F407xx_Lib\CMSIS\Include;.\STM32F407xx_Lib\CMSIS\ST\STM32F4xx\Include;.\STM32F407xx_Lib\STM32F4xx_StdPeriph_Driver\inc;.\STM32F407xx_Lib\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./STM32F407xx_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_exti.c
    ./STM32F407xx_Lib/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./STM32F407xx_Lib/CMSIS/ST/STM32F4xx/Source/: system_stm32f4xx.c
    ./STM32F407xx_Lib/STM32F4-Discovery/: stm32f4_discovery_lis302dl.c
  group FreeRTOS
    ./FreeRTOS/Source/: queue.c tasks.c list.c croutine.c
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App
    ./: main.c
