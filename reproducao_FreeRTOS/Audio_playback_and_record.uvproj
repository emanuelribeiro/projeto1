# Keil uVision project Audio_playback_and_record.uvproj, settings and files
target MEDIA_intFALSH (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: MEDIA_intFLASH
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX,  MEDIA_IntFLASH, USE_DEFAULT_TIMEOUT_CALLBACK, RVDS_ARMCM4F
  c include: .\STM32F407xx_Lib\CMSIS\Include;.\STM32F407xx_Lib\CMSIS\ST\STM32F4xx\Include;.\STM32F407xx_Lib\STM32F4xx_StdPeriph_Driver\inc;.\STM32F407xx_Lib\STM32F4-Discovery;.\inc;.\FreeRTOS;.\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: audio_sample.c main.c stm32f4xx_it.c system_stm32f4xx.c waveplayer.c
  group STM32F4-Discovery
    ./STM32F407xx_Lib/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c libPDMFilter_Keil.lib
  group STM32F4xx_StdPeriph_Driver
    ./STM32F407xx_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group MDK-ARM
    ./STM32F407xx_Lib/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group FreeRTOS
    ./FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
target MEDIA_USB_KEY (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: MEDIA_USB_KEY
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, MEDIA_IntFLASH, __FPU_PRESENT=0
  c include: ..\inc;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Utilities\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
